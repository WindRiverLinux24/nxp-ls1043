KBRANCH:nxp-ls1043  = "v5.15/standard/preempt-rt/nxp-sdk-5.15/nxp-soc"

require linux-yocto-nxp-ls1043.inc
