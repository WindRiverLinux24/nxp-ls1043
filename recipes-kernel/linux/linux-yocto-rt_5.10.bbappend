KBRANCH_nxp-ls1043  = "v5.10/standard/preempt-rt/nxp-sdk-5.10/nxp-soc"

require linux-yocto-nxp-ls1043.inc

LINUX_VERSION_nxp-ls1043 ?= "5.10.x"
