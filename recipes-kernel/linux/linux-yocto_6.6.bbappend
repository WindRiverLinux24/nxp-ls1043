KBRANCH:nxp-ls1043  = "v6.6/standard/nxp-sdk-6.6/nxp-soc"

require linux-yocto-nxp-ls1043.inc
