#
# Copyright (C) 2018 Wind River Systems, Inc.
#

require linux-yocto-nxp-ls1043.inc

KBRANCH_nxp-ls1043 = "v4.18/standard/nxp-ls/lsdk-1812/${KMACHINE}"
