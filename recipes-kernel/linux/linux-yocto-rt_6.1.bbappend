KBRANCH:nxp-ls1043  = "v6.1/standard/preempt-rt/nxp-sdk-6.1/nxp-soc"

require linux-yocto-nxp-ls1043.inc
