require linux-yocto-nxp-ls1043.inc

KBRANCH_nxp-ls1043  = "v5.2/standard/preempt-rt/nxp-lsdk-20.04/nxp-ls1043"
