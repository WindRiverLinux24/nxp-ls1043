COMPATIBLE_MACHINE_nxp-ls1043 = "nxp-ls1043"
DEPENDS_append_nxp-ls1043 = " change-file-endianess-native dtc-native tcl-native"


