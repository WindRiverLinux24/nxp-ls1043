COMPATIBLE_MACHINE_nxp-ls1043 = "nxp-ls1043"
M = "ls1043ardb"
