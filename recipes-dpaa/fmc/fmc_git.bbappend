COMPATIBLE_MACHINE:nxp-ls1043 = "nxp-ls1043"
EXTRA_OEMAKE_PLATFORM:nxp-ls1043 = "ls1043"
