COMPATIBLE_MACHINE:nxp-ls1043 = "nxp-ls1043"
TARGET_ARCH_FMLIB:nxp-ls1043 = "arm"
