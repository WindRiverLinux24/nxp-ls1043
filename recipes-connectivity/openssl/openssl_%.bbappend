SRC_URI:remove:nxp-ls1043 = "file://0002-e_devcrypto-add-support-for-TLS1.2-algorithms-offloa.patch"
