SRC_URI:remove:nxp-ls1043 = "file://defconfig"
